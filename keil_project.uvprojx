# Keil uVision project keil_project.uvprojx, settings and files
target Sources (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil_project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c include: .\Sources\inc;.\Sources\ft801_src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./Sources/src/: main.c spi.c spi_with_interrutps.c gpio_exti.c
  group inc
    ./Sources/inc/: spi.h spi_with_interrupts.h gpio_exti.h
  group FT801_src
    ./Sources/ft801_src/: ft801_gpu.h ft801_api.c ringBuffer_api.c ringBuffer_api.h ft801_api_dl.c ft801_api_dl.h ft801_api_cmd.c ft801_api_cmd.h
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.0
